# Keil uVision project BSMU_H750IB.uvprojx, settings and files
target BSMU_H750IB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750IBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: BSMU_H750IB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx,NDEBUG
  c include: ../Core/Inc;../LWIP/App;../LWIP/Target;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/BSP/Components/lan8742;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/compat/posix;../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa;../Middlewares/Third_Party/LwIP/src/include/compat/posix/net;../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys;../Middlewares/Third_Party/LwIP/src/include/compat/stdc;../Middlewares/Third_Party/LwIP/system/arch;../Drivers/CMSIS/Include;../Drivers/BSP/Components/GT911;../Drivers/BSP/Components/LCD;../Drivers/BSP/Components/w9825G6kh;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../TouchGFX/gui/include/gui/common;../Drivers/BSP/Components/my_delay;../Drivers/BSP/Components/my_iic;../Drivers/BSP/Components/AT_module_4g;../Drivers/BSP/Components/AT24CXX;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include;../Drivers/BSP/Components/RS485;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;..\agile_modbus\inc;..\agile_modbus\util
  asm include: ..\Core\Inc;../Core/Inc
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: client.c CAN_Control.c station_ctl.c main.c gpio.c freertos.c crc.c dma.c dma2d.c fdcan.c fmc.c ltdc.c quadspi.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/LWIP/Target
    ../LWIP/Target/: ethernetif.c
  group Application/User/LWIP/App
    ../LWIP/App/: lwip.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/GT911/: GT911.c
    ../Drivers/BSP/Components/LCD/: LCD.c
    ../Drivers/BSP/Components/w9825G6kh/: w9825G6kh.c
    ../Drivers/BSP/Components/my_delay/: my_delay.c
    ../Drivers/BSP/Components/my_iic/: my_iic.c at24cxx_iic.c
    ../Drivers/BSP/Components/AT_module_4g/: AT_module_4g.c
    ../Drivers/BSP/Components/AT24CXX/: AT24CXX.c
    ../Drivers/BSP/Components/RS485/: RS485.c modbus.c
    ../Drivers/BSP/Components/lan8742/: lan8742.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_fdcan.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group gui
    ../touchgfx/gui/src/containers/: customcontainer1.cpp customcontainer2.cpp customcontainer3.cpp customcontainer4.cpp keyboard.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/mainscreen_screen/: mainscreenpresenter.cpp mainscreenview.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/setting_screen/: settingpresenter.cpp settingview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_stfangso_ttf_32_4bpp_0.cpp font_stfangso_ttf_32_4bpp_10.cpp font_stfangso_ttf_32_4bpp_12.cpp font_stfangso_ttf_32_4bpp_13.cpp font_stfangso_ttf_32_4bpp_14.cpp font_stfangso_ttf_32_4bpp_15.cpp font_stfangso_ttf_32_4bpp_17.cpp font_stfangso_ttf_32_4bpp_18.cpp font_stkaiti_ttf_40_4bpp_0.cpp font_stkaiti_ttf_40_4bpp_10.cpp font_stkaiti_ttf_40_4bpp_11.cpp font_stkaiti_ttf_40_4bpp_12.cpp font_stkaiti_ttf_40_4bpp_14.cpp font_stkaiti_ttf_40_4bpp_15.cpp font_stkaiti_ttf_40_4bpp_17.cpp font_stkaiti_ttf_40_4bpp_18.cpp font_stkaiti_ttf_40_4bpp_9.cpp font_stsong_ttf_18_4bpp_0.cpp font_stsong_ttf_18_4bpp_10.cpp font_stsong_ttf_18_4bpp_12.cpp font_stsong_ttf_18_4bpp_15.cpp font_stsong_ttf_18_4bpp_9.cpp font_stsong_ttf_22_8bpp_0.cpp font_stsong_ttf_22_8bpp_12.cpp font_stsong_ttf_22_8bpp_19.cpp font_stsong_ttf_22_8bpp_9.cpp font_stxihei_ttf_24_4bpp_0.cpp font_stxihei_ttf_24_4bpp_10.cpp font_stxihei_ttf_24_4bpp_11.cpp font_stxihei_ttf_24_4bpp_12.cpp font_stxihei_ttf_24_4bpp_13.cpp font_stxihei_ttf_24_4bpp_14.cpp font_stxihei_ttf_24_4bpp_15.cpp font_stxihei_ttf_24_4bpp_17.cpp font_stxihei_ttf_24_4bpp_18.cpp font_stxihei_ttf_24_4bpp_31.cpp font_stxihei_ttf_24_4bpp_9.cpp font_times_18_4bpp_0.cpp font_times_18_4bpp_4.cpp font_times_36_8bpp_0.cpp font_timesbd_18_4bpp_0.cpp font_timesbd_22_4bpp_0.cpp font_verdana_10_4bpp_0.cpp font_verdana_20_4bpp_0.cpp font_verdana_40_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_stfangso_ttf_32_4bpp.cpp kerning_stkaiti_ttf_40_4bpp.cpp kerning_stsong_ttf_18_4bpp.cpp kerning_stsong_ttf_22_8bpp.cpp kerning_stxihei_ttf_24_4bpp.cpp kerning_times_18_4bpp.cpp kerning_times_36_8bpp.cpp kerning_timesbd_18_4bpp.cpp kerning_timesbd_22_4bpp.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_40_4bpp.cpp table_stfangso_ttf_32_4bpp.cpp table_stkaiti_ttf_40_4bpp.cpp table_stsong_ttf_18_4bpp.cpp table_stsong_ttf_22_8bpp.cpp table_stxihei_ttf_24_4bpp.cpp table_times_18_4bpp.cpp table_times_36_8bpp.cpp table_timesbd_18_4bpp.cpp table_timesbd_22_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_40_4bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_battery_empty100x80.cpp image_bcmu_but_bg_1.cpp image_bcmu_but_bg_2.cpp image_benji_bg.cpp image_bg_805x480.cpp image_bg_94x487.cpp image_biaoti.cpp image_bmu_but_1.cpp image_bmu_but_2.cpp image_ethon_50x50.cpp image_info_bg.cpp image_legend_2.cpp image_menu_expand_1.cpp image_menu_expand_2.cpp image_setting_1.cpp image_setting_2.cpp image_station.cpp image_station_1.cpp image_station_2.cpp image_wifion.cpp
    ../touchgfx/generated/gui_generated/src/containers/: customcontainer1base.cpp customcontainer2base.cpp customcontainer3base.cpp customcontainer4base.cpp keyboardbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/images/src/__designer/: image_blue_buttons_round_edge_small.cpp image_blue_buttons_round_edge_small_pressed.cpp image_blue_slider_horizontal_large_indicators_slider2_round_nob.cpp image_blue_slider_horizontal_large_slider2_round_back.cpp image_blue_slider_horizontal_large_slider2_round_fill.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/mainscreen_screen/: mainscreenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/setting_screen/: settingviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group agile_modbus
    ../agile_modbus/src/: agile_modbus.c agile_modbus_rtu.c agile_modbus_tcp.c
    ../agile_modbus/util/: agile_modbus_slave_util.c
software components: CMSIS:CORE 4.3.0
